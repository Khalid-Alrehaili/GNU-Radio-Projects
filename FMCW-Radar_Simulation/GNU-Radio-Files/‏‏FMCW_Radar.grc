options:
  parameters:
    author: Khalid Alrehaili, Hatem Aljuhani, Mohammed Atif
    generate_options: qt_gui
    id: FMCW_Radar
    output_language: python
    title: FMCW_Radar
  states: {}

blocks:
- name: Bandwidth
  id: variable
  parameters:
    value: 6e6*5
  states: {}
- name: PRF
  id: variable
  parameters:
    value: '2560'
  states: {}
- name: anntena_gain
  id: variable
  parameters:
    value: '500'
  states: {}
- name: avg_downbeat
  id: variable
  parameters:
    value: avg_beat.downbeat_detect(beat_detection_0.detect(tri_prob_func_0), probe_func_0)
  states: {}
- name: avg_upbeat
  id: variable
  parameters:
    value: avg_beat.upbeat_detect(beat_detection.detect(tri_prob_func), probe_func_0)
  states: {}
- name: beatfrequency_gui
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,1
    label: 'Beat Frequency (Hz): '
    type: int
    value: int(probe_func)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: 256*1.5
  states: {}
- name: distance_calculated
  id: variable
  parameters:
    value: avg_beat.distance_calculator(Bandwidth, PRF, avg_downbeat, avg_upbeat)
  states: {}
- name: distance_gui
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: 'Distance (m): '
    type: real
    value: round(distance_calculated,2)
  states: {}
- name: downbeat_gui
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,1,1,1
    label: 'average beat (-):  '
    type: int
    value: int(avg_downbeat)
  states: {}
- name: object1
  id: variable
  parameters:
    value: object_module.object([0, 0, 30], -20,10)
  states: {}
- name: pi
  id: variable
  parameters:
    value: math.pi
  states: {}
- name: power
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: probe_func
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: probe_func_0
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e9
  states: {}
- name: signal_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: tri_prob_func
  id: variable_function_probe
  parameters:
    block_id: tri_prob
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: tri_prob_func_0
  id: variable_function_probe
  parameters:
    block_id: tri_prob_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: upbeat_gui
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,1
    label: 'average beat (+): '
    type: int
    value: int(avg_upbeat)
  states: {}
- name: velocity_calculated
  id: variable
  parameters:
    value: avg_beat.Velocity_calculator(signal_freq,avg_downbeat,avg_upbeat)
  states: {}
- name: velocity_gui
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: 'Velocity (m/s): '
    type: real
    value: round(avg_beat.Velocity_calculator(signal_freq,avg_downbeat,avg_upbeat), 2)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_pll_freqdet_cf_0_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pi/200
    min_freq: '-pi/200'
    w: pi/50
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: (Bandwidth / signal_freq)
    freq: PRF
    offset: (1 - (Bandwidth / (signal_freq*2)))
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: avg_beat
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy as np\nfrom scipy.constants import speed_of_light\n\n#UpBeat Detector\nupbeat_values = np.array([1 , 2])\nupbeat = 0\nprevious_lvl = 0\ndef reject_outliers(data, m=2):\n\treturn data[abs(data - np.mean(data)) < m * np.std(data)]\n\ndef upbeat_detect(stage, probe_lvl):\n\tglobal upbeat, upbeat_values, previous_lvl\n\tif stage == 1:\n\t\tupbeat_values = np.append(upbeat_values, [probe_lvl])\n\t\tprevious_lvl = probe_lvl\n\tif stage == -1:\n\t\tupbeat_values = reject_outliers(upbeat_values)\n\t\tupbeat = np.mean(upbeat_values)\n\treturn upbeat\n\n# Downbeat Detector\ndownbeat_values = np.array([1 , 2])\ndownbeat = 0\nprevious_lvl = 0\ndef reject_outliers(data, m=2):\n\treturn data[abs(data - np.mean(data)) < m * np.std(data)]\n\ndef downbeat_detect(stage, probe_lvl):\n\tglobal downbeat, downbeat_values, previous_lvl\n\tif stage == -1:\n\t\tdownbeat_values = np.append(downbeat_values, [probe_lvl])\n\t\tprevious_lvl = probe_lvl\n\tif stage == 1:\n\t\tdownbeat_values = reject_outliers(downbeat_values)\n\t\tdownbeat = np.mean(downbeat_values)\n\treturn downbeat\n\n# Velocity Calculator\ndef Velocity_calculator(fc, downbeat, upbeat):\n\tvelocity = speed_of_light*(-1*downbeat-upbeat)/(4*fc)\n\treturn np.round(velocity, 3)\n\n# Distance Calculator\ndef distance_calculator(Bandwidth, PRF, downbeat, upbeat):\n\tdistance = (speed_of_light/(4*2*Bandwidth*PRF))*(upbeat-downbeat)\n\treturn np.round(distance, 3)\n\n\n\n\n    \n    \n"
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2.42e9
    low_cutoff_freq: 2.38e9
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 5e6
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2.42e9
    low_cutoff_freq: 2.38e9
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 5e6
    win: window.WIN_HAMMING
  states: {}
- name: beat_detection
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\npoint1 = 0\n\ndef detect(probe_lvl):\n    global point1\n    if probe_lvl > point1:\n        point1 = probe_lvl\n        return 1\n    elif probe_lvl < point1:\n        point1 = probe_lvl\n        return -1\n    else:\n        return 0\n        \n    \n    \n"
  states: {}
- name: beat_detection_0
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\npoint1 = 0\n\ndef detect(probe_lvl):\n    global point1\n    if probe_lvl > point1:\n        point1 = probe_lvl\n        return 1\n    elif probe_lvl < point1:\n        point1 = probe_lvl\n        return -1\n    else:\n        return 0\n        \n    \n    \n"
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(object1.distance()*2*samp_rate/speed_of_light)
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: object1.frequency_shift(signal_freq)
    sample_rate: samp_rate
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate/100000/decimation)
    max_iter: '40000'
    scale: 1/(samp_rate/100000/decimation)
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.sqrt(57)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/(2*pi)/decimation
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: math.sqrt(57)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: math.sqrt(anntena_gain)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(object1.FSPL(signal_freq))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(object1.FSPL(signal_freq))
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: power/1000
    samp_rate: samp_rate
    sensitivity: 2*pi*signal_freq
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 2.4e6
    decim: '1'
    gain: '1'
    nthreads: '4'
    samp_rate: samp_rate/decimation
    type: ccc
    width: 1e6
    win: window.WIN_HAMMING
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: int(decimation)
    taps: '1'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '64'
    taps: '1'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import myobjects
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from scipy.constants import speed_of_light
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e9
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 57 =17.55 dB=8.65 dBgnu
  states: {state: disabled}
- name: note_0_1
  id: note
  parameters:
    note: 57 =17.55 dB=8.65 dBgnu
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    note: anntena gain
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: going to target
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: returning from target
  states: {}
- name: note_1_0_1
  id: note
  parameters:
    note: 'delay of signal in '
  states: {}
- name: note_1_0_1_0
  id: note
  parameters:
    note: Doppler Shift
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: DSP Stage
  states: {state: disabled}
- name: object_module
  id: epy_module
  parameters:
    source_code: "import math\nfrom scipy.constants import speed_of_light\nc = speed_of_light\n\nclass object():\n    def __init__(self, position : list, radial_velocity : float, area : float):\n        self.position = position\n        self.area = area\n        self.radial_velocity = radial_velocity\n\n    def get_position(self):\n        return self.position\n\n    def get_speed(self):\n        return self.speed\n\n    def get_area(self):\n        return self.area\n\n    def distance(self):\n        return math.sqrt(math.pow(self.position[0], 2)+ math.pow(self.position[1], 2)+ math.pow(self.position[2], 2))\n\n    def FSPL(self, frequency):\n        FSPLv = 4*math.pi*frequency*self.distance()/c\n        return FSPLv\n\n    def get_radial_velocity(self):\n        return self.radial_velocity\n\n    def frequency_shift(self, frequency):\n        answer = 2*self.radial_velocity*frequency/speed_of_light\n        return answer\n    \n"
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Sent
    type: complex
    ymax: '40'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: ' '
    legend: 'False'
    name: '"Echo Signal in Frequency Domain"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: I
    label2: Q
    name: '"Transmitted Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/decimation
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Frequency"'
    size: '1024'
    srate: samp_rate/decimation
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.00125'
    ymin: '0.99875'
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    label1: I Signal
    label2: Q Signal
    name: '"Echo Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: tri_prob
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: tri_prob_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: '3'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: '3'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_pll_freqdet_cf_0_0, '0', blocks_moving_average_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_2, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_2_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_4, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_delay_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_multiply_const_vxx_2_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', probe_signal, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_2_0_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_vco_c_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0_1, '0']
- [blocks_vco_c_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_3, '0']
- [filter_fft_low_pass_filter_0, '0', analog_pll_freqdet_cf_0_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [fir_filter_xxx_0, '0', filter_fft_low_pass_filter_0, '0']
- [fir_filter_xxx_0_0_0, '0', qtgui_time_sink_x_2, '0']
- [fir_filter_xxx_0_0_0, '0', tri_prob, '0']
- [fir_filter_xxx_0_0_0, '0', tri_prob_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [virtual_source_0_0_0, '0', fir_filter_xxx_0_0_0, '0']
- [virtual_source_1, '0', band_pass_filter_0_0, '0']
- [virtual_source_1_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
