options:
  parameters:
    author: khalid alrehaili
    generate_options: qt_gui
    id: FM_Receiver
    output_language: python
    title: FM_Receiver
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: amp
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    rangeType: int
    start: int(80e6)
    step: int(0.1e6)
    stop: int(110e6)
    value: int(96.8e6)
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf_gain
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3*decimation)
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: threshold
    rangeType: int
    start: '-120'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation
    quad_rate: int(samp_rate)
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '5'
    deemph_tau: '75e-6'
    quad_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:1,0
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 120e3
    center_freq0: freq
    dc_offs_enb0: disabled
    dev_addr: '"serial=321CB0C"'
    iq_imbal_enb0: auto
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
