options:
  parameters:
    author: khalid alrehaili
    generate_options: qt_gui
    id: FM_Receiver
    output_language: python
    title: FM_Receiver
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: amp
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: audio_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 10e3
    low_cutoff_freq: '200'
    samp_rate: quad_rate
    type: band_pass
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    rangeType: int
    start: int(80e6)
    step: int(0.1e6)
    stop: int(110e6)
    value: int(96.8e6)
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*interpolation
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf_gain
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pi
    min_freq: '-pi'
    w: pi/50
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: quad_rate/75e3*1/(2*pi)
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: interpolation
    taps: audio_filter
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: quad_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 160e3
    center_freq0: freq
    dc_offs_enb0: disabled
    dev_addr: '"serial=321CB0C"'
    iq_imbal_enb0: auto
    rx_agc0: Enabled
    samp_rate: quad_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', analog_pll_freqdet_cf_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
