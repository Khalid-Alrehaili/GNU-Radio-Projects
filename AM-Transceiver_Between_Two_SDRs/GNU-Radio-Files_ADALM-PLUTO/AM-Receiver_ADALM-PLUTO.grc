options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: AM_Receiver_ADALM_PLUTO
    output_language: python
    title: AM_Receiver_ADALM_PLUTO
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: round((frequency_detector.frequency_detector(func, vector_length))*samp_rate/vector_length, 2)
  states: {}
- name: freq_Rx
  id: variable_qtgui_range
  parameters:
    label: freq_Rx
    start: 47e6
    step: 1e6
    stop: 6e9
    value: (0.591e9)
  states: {}
- name: func
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '60'
    value: '0'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3*interpolation)
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: freq
    type: real
    value: freq
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: 1024*64
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '2'
    gain: '1'
    high_cutoff_freq: 5e3
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vector_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
    vlen: vector_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-10*log10(vector_length)'
    n: '10'
    vlen: vector_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n \n \nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block Envelope Detector \"\"\"\n \n    def __init__(self, threshold=0.0, mode=0, coeff=0.15):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Envelope Detector',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n \n        self.ry = 0\n        self.threshold = threshold\n        self.mode = mode\n        self.coeff = coeff\n \n    def work(self, input_items, output_items):\n        \"\"\"Envelope Detect with Half/Full Wave Rectifier\"\"\"\n        buf = [0] * len(output_items[0])\n        a0 = self.coeff\n        b1 = 1 - a0\n        # Rectify the signal. Mode 0 is half-wave, Mode 1 is full-wave\n        for i in range (0, len(input_items[0])) :\n            if self.mode == 1:\n                buf[i] = abs(input_items[0][i])\n            else:\n                if input_items[0][i] > self.threshold:\n                    buf[i] = input_items[0][i]\n                else:\n                    buf[i] = 0\n        # Simulate simple RC filter with a variable decay coefficient\n        for i in range(0, len(output_items[0])):\n            if i==0:\n                output_items[0][i] = a0*buf[i] + b1*self.ry\n            else:\n                output_items[0][i] = a0*buf[i] + b1*output_items[0][i-1]\n \n        i = len(output_items[0])-1\n        self.ry = output_items[0][i]\n \n        return len(output_items[0])"
    coeff: coeff
    mode: '1'
    threshold: '0'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vector_length)
  states: {}
- name: frequency_detector
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\ndef frequency_detector(signal, vector_length):\n\tglobal a, b\n\ta = 0\n\tb = 0\n\tif type(signal) is list:\n\t\ta = max(signal)\n\t\tb = signal.index(a)-vector_length/2\n\treturn b\n\n"
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(freq_Rx)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: probe_signal
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: vector_length
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: vector_length
    x_start: '-vector_length/2'
    x_step: '1'
    ymin: '-10'
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '0', band_pass_filter_0, '0']
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_0, '0', probe_signal, '0']
- [blocks_integrate_xx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_integrate_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_float_0, '0']
- [iio_pluto_source_0, '0', blocks_stream_to_vector_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
