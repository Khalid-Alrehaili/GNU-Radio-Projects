options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: AM_Transmitter_USRP_B200mini
    output_language: python
    title: AM_Transmitter_USRP_B200mini
  states: {}

blocks:
- name: Gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: freq_Tx
  id: variable_qtgui_range
  parameters:
    label: freq_Tx
    start: 47e6
    step: 1e6
    stop: 6e9
    value: (0.591e9)
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3*interpolation)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: audio.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    gain: '2'
    interp: interpolation
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Add Carrier
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    alias: Transmitted Signal
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"Transmitted Signal"'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_Tx
    gain0: Gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', low_pass_filter_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
