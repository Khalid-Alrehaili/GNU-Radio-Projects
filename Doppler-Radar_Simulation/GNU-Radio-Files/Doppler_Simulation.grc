options:
  parameters:
    author: 'Khalid Alrehaili '
    generate_options: qt_gui
    id: Doppler_Radar_Simulation
    output_language: python
    title: Doppler Radar Simulation
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '100'
  states: {}
- name: fc
  id: variable
  parameters:
    value: int(2.4e9)
  states: {}
- name: freq
  id: variable
  parameters:
    value: round((frequency_detector.frequency_detector(func, vector_length, threshold))*samp_rate/vector_length/decimation, 2)
  states: {state: disabled}
- name: freq_0
  id: variable
  parameters:
    value: round(frequency_detector_0.frequency_detector(func_0),2)
  states: {}
- name: func
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '60'
    value: '0'
  states: {state: disabled}
- name: func_0
  id: variable_function_probe
  parameters:
    block_id: probe_signal_0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: lambda1
  id: variable
  parameters:
    value: c/fc
  states: {}
- name: object1
  id: variable
  parameters:
    value: myobjects.object([0, 0, 10], -40/3.6,1)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (4.9e9)
  states: {}
- name: speed
  id: variable
  parameters:
    value: freq*lambda1/2*3.6
  states: {state: disabled}
- name: speed_0
  id: variable
  parameters:
    value: freq_0*lambda1/2*3.6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '-100'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: freq
    type: real
    value: freq
  states: {state: disabled}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    label: 'speed: '
    type: real
    value: speed
  states: {state: disabled}
- name: variable_qtgui_label_0_0_0
  id: variable_qtgui_label
  parameters:
    label: 'speed: '
    type: string
    value: str(round(speed_0, 2))+" Km/h"
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    label: 'doppler shift: '
    type: string
    value: str(round(freq_0, 2))+" Hz"
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: 1024*128*2
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.0001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pi/2
    min_freq: '-pi/2'
    w: pi/100000
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vector_length
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(object1.distance()*2*samp_rate/c)
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: object1.frequency_shift(fc)
    sample_rate: samp_rate
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
    vlen: vector_length
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/(2*pi*decimation)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/((object1.FSPL(fc)))
    type: complex
  states: {state: bypassed}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-10*log10(vector_length)'
    n: '10'
    vlen: vector_length
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_length
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vector_length)
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: '1'
    type: ccf
  states: {}
- name: frequency_detector
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\ndef frequency_detector(signal, vector_length, threshold):\n\t\n\tglobal a, b\n\ta = 0\n\tb = 0\n\tif type(signal) is list:\n\t\ta = max(signal)\n\t\tif a < threshold:\n\t\t\treturn 5e3/4\n\t\t\n\t\tb = signal.index(a)-vector_length/2\n\treturn b\n\n"
  states: {state: disabled}
- name: frequency_detector_0
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\ndef frequency_detector(signal):\n\treturn signal\n\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from scipy.constants import c
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_2
  id: import
  parameters:
    imports: import myobjects
  states: {}
- name: probe_signal
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: vector_length
  states: {state: disabled}
- name: probe_signal_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: vector_length
    x_start: '-vector_length/2'
    x_step: '1'
    ymin: '-10'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_delay_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_add_xx_0, '0']
- [blocks_integrate_xx_0, '0', probe_signal, '0']
- [blocks_integrate_xx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', probe_signal_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_delay_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_integrate_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_freqdet_cf_0, '0']
- [fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0_1, '0', blocks_multiply_conjugate_cc_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
