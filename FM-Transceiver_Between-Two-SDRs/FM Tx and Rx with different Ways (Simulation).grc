options:
  parameters:
    author: kald0n
    generate_options: qt_gui
    id: testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Switch
  id: variable_qtgui_range
  parameters:
    label: Switch
    rangeType: int
    start: '0'
    step: '1'
    stop: '2'
    value: '0'
  states: {}
- name: audio_filter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_interpolated/(interpolation*2)
    gain: '10'
    samp_rate: samp_rate_interpolated
    width: samp_rate_interpolated/(interpolation*4)
    win: window.WIN_HAMMING
  states: {}
- name: audio_filter_1
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_interpolated/(interpolation*2)
    gain: '1'
    samp_rate: samp_rate_interpolated
    width: samp_rate_interpolated/(interpolation*4)
    win: window.WIN_HAMMING
  states: {}
- name: bandwidth_loob
  id: variable_qtgui_range
  parameters:
    label: bandwidth_loob
    start: pi/1000
    step: pi/1000
    stop: pi
    value: pi/10
  states: {}
- name: freq1
  id: variable_qtgui_range
  parameters:
    label: freq1
    start: '-75e3'
    step: '1'
    stop: 75e3
    value: '0'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_interpolated
  id: variable
  parameters:
    value: samp_rate * interpolation
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pi
    min_freq: '-pi'
    w: bandwidth_loob
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate_interpolated
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:1,0
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/75e3*1/(2*pi)*10
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: Switch
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate*10
    sensitivity: 2*pi*75e3
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/kald0n/Downloads/gitfiles/GNU-Radio-Projects/FM-Transceiver_Between-Two-SDRs/GNU-Radio-Files_ADALM-PLUTO/audio.mp3
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: interpolation
    taps: audio_filter_1
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '10'
    taps: audio_filter
    type: fff
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_selector_0, '0']
- [analog_nbfm_rx_0_0, '0', blocks_selector_0, '1']
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_tx_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', fir_filter_xxx_0, '0']
- [blocks_selector_0, '0', audio_sink_0, '0']
- [blocks_vco_c_0, '0', analog_nbfm_rx_0_0, '0']
- [blocks_vco_c_0, '0', analog_pll_freqdet_cf_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', interp_fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_selector_0, '2']
- [interp_fir_filter_xxx_0, '0', blocks_vco_c_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
