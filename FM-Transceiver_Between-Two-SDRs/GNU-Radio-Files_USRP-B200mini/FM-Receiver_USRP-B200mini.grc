options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: FM_Receiver_USRP_B200mini
    output_language: python
    title: FM_Receiver_USRP_B200mini
  states: {}

blocks:
- name: audio_filter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: quad_rate/(interpolation*2)
    gain: '1'
    samp_rate: quad_rate
    width: quad_rate/(interpolation*4)
    win: window.WIN_HAMMING
  states: {}
- name: freq_Rx
  id: variable_qtgui_range
  parameters:
    label: freq_Rx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(1.59e9)
  states: {}
- name: freq_tone
  id: variable_qtgui_range
  parameters:
    label: freq_tone
    start: '-1e6'
    step: '100'
    stop: 1e6
    value: '0'
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: gain_slider
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*interpolation
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pi
    min_freq: '-pi'
    w: '-pi/100'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/75e3*1/(2*pi)*10
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: interpolation
    taps: audio_filter
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq_Rx
    rx_agc0: Enabled
    samp_rate: quad_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', audio_sink_0_0, '0']
- [uhd_usrp_source_0, '0', analog_pll_freqdet_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
