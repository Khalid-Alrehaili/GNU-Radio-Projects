options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: FM_Receiver_USRP_B200mini
    output_language: python
    title: FM_Receiver_USRP_B200mini
  states: {}

blocks:
- name: freq_Rx
  id: variable_qtgui_range
  parameters:
    label: freq_Rx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(1.59e9)
  states: {}
- name: freq_tone
  id: variable_qtgui_range
  parameters:
    label: freq_tone
    start: '-1e6'
    step: '100'
    stop: 1e6
    value: '0'
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: gain_slider
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: 10e3
    interp: '1'
    low_cutoff_freq: '100'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq_Rx
    rx_agc0: Enabled
    samp_rate: quad_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', band_pass_filter_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_0, '0', audio_sink_0_0, '0']
- [uhd_usrp_source_0, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
