options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: FM_Transmitter_USRP_B200mini
    output_language: python
    title: FM_Transmitter_USRP-B200mini
  states: {}

blocks:
- name: Gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: audio_filter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: quad_rate/(interpolation*2)
    gain: interpolation
    samp_rate: quad_rate
    width: quad_rate/(interpolation*4)
    win: window.WIN_HAMMING
  states: {}
- name: freq_Tx
  id: variable_qtgui_range
  parameters:
    label: freq_Tx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(1.59e9)
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*interpolation
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: quad_rate
    sensitivity: 2*pi*75e3
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: audio.mp3
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interpolation
    taps: audio_filter
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 160e3
    center_freq0: freq_Tx
    gain0: Gain
    gain_type0: normalized
    samp_rate: quad_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_vco_c_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_vco_c_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
