options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: FM_Transmitter_ADALM_PLUTO
    output_language: python
    title: FM_Transmitter_ADALM_PLUTO
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    label: attenuation
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: freq_Tx
  id: variable_qtgui_range
  parameters:
    label: freq_Tx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(1.59e9)
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: 10e3
    interp: '1'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: quad_rate
    sensitivity: 2*pi*75e3
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: audio.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: attenuation
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq_Tx)
    samplerate: quad_rate
    type: fc32
    uri: 192.168.2.2
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}

connections:
- [analog_wfm_tx_0, '0', iio_pluto_sink_0, '0']
- [band_pass_filter_0, '0', analog_wfm_tx_0, '0']
- [band_pass_filter_0, '0', blocks_vco_c_0, '0']
- [blocks_vco_c_0, '0', iio_pluto_sink_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
