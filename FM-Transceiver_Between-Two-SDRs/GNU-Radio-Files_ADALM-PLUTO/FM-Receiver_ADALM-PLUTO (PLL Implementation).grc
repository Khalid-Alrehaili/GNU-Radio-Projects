options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: FM_Receiver_ADALM_PLUTO
    output_language: python
    title: FM_Receiver_ADALM_PLUTO
  states: {}

blocks:
- name: audio_filter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 9e3
    gain: '1'
    samp_rate: quad_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: freq_Rx
  id: variable_qtgui_range
  parameters:
    label: freq_Rx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(1.234e9)
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    label: gain_slider
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*interpolation
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pi
    min_freq: '-pi'
    w: pi/10
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: quad_rate/75e3*1/(2*pi)
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: interpolation
    taps: audio_filter
    type: fff
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(freq_Rx)
    gain1: '''slow_attack'''
    manual_gain1: '71'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: quad_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: quad_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', audio_sink_0_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_pll_freqdet_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
