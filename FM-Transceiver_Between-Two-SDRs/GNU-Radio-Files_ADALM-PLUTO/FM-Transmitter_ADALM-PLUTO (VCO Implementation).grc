options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: FM_Transmitter_ADALM_PLUTO
    output_language: python
    title: FM_Transmitter_ADALM_PLUTO
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    label: attenuation
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: audio_filter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: quad_rate/(interpolation*2)
    gain: interpolation
    samp_rate: quad_rate
    width: quad_rate/(interpolation*4)
    win: window.WIN_HAMMING
  states: {}
- name: freq_Tx
  id: variable_qtgui_range
  parameters:
    label: freq_Tx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(1.234e9)
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*interpolation
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: quad_rate
    sensitivity: 2*pi*75e3
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: audio.mp3
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: attenuation
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq_Tx)
    samplerate: quad_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interpolation
    taps: audio_filter
    type: fff
  states: {}

connections:
- [blocks_vco_c_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_wavfile_source_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_vco_c_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
