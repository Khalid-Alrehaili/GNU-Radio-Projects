options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: FM_Transceiver
    output_language: python
    title: FM Transceiver
  states: {}

blocks:
- name: Gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: freq_Rx
  id: variable_qtgui_range
  parameters:
    label: freq_Rx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(2.4e9)
  states: {}
- name: freq_Tx
  id: variable_qtgui_range
  parameters:
    label: freq_Tx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(2.4e9)
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*interpolation
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: quad_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../audio.mp3
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"transmitted"'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_Tx
    gain0: Gain
    gain_type0: normalized
    samp_rate: quad_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq_Rx
    rx_agc0: Enabled
    samp_rate: quad_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
