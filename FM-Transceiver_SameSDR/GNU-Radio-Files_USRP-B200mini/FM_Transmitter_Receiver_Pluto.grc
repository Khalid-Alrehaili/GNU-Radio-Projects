options:
  parameters:
    author: Khalid Alrehaili
    generate_options: qt_gui
    id: FM_Transceiver
    output_language: python
    title: FM Transceiver
  states: {}

blocks:
- name: Rx_Amp
  id: variable_qtgui_range
  parameters:
    label: Rx_Amp
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: Tx_Amp
  id: variable_qtgui_range
  parameters:
    label: Tx_Amp
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: amplification_Rx
  id: variable_qtgui_range
  parameters:
    label: amplification_Rx
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: amplification_Tx
  id: variable_qtgui_range
  parameters:
    label: amplification_Tx
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: attenuation
  id: variable_qtgui_range
  parameters:
    label: attenuation
    start: '0'
    step: '1'
    stop: '89'
    value: '70'
  states: {}
- name: freq_Rx
  id: variable_qtgui_range
  parameters:
    label: freq_Rx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(2.4e9)
  states: {}
- name: freq_Tx
  id: variable_qtgui_range
  parameters:
    label: freq_Tx
    start: 47e6
    step: 25e6
    stop: 6e9
    value: int(2.4e9)
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate*5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: quad_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplification_Tx
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplification_Rx
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: audio.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"transmitted"'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_Tx
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq_Rx
    gain0: Rx_Amp
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_wfm_rcv_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
